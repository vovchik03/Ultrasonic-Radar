<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F103C8Tx_Radar.ewp</path>
  </project>
  <batchBuild />
</workspace>
